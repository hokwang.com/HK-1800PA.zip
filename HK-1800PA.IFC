Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-1800PA.IFC
Time: 2022-01-04T07:56:09
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 1800PA外殼
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 22外殼螺絲 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: M4×5螺絲
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 二合一機板
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 出風口柵門
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 底座
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 新型TIMER外殼B
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 風扇
In: Default Storey
PredefinedType: ELEMENT; Material: 0
